Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: SD-KCHF-05-model.ifc
Time: 2026-09-04T11:44:45+00:00
Author: OOO PKF ORION, zavod-orion.ru
Organization: OOO PKF ORION, zavod-orion.ru
Written by: AutoCAD 2024
Made in: AutoCAD 2024
Authorization: OOO PKF ORION, zavod-orion.ru

# IfcBuildingElementProxy, SD-KCHF-05 Качалка на пружине «Кузнечик» · исполнение 1 Эконом
In: Площадка
Pset_ManufacturerTypeInformation - Manufacturer: ООО «ПКФ «ОРИОН» · zavod-orion.ru · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: SD-KCHF-05; ModelReference: Качалка на пружине «Кузнечик» · исполнение 1 Эконом; ProductionYear: 2026
